# IAR project PinControl.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\alfinant\GpioSet\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; LUMBERG
  XLINK.XclFile: $TOOLKIT_DIR$\alfinant\PinControl\test.xcl
  group (top)
    ./: func.asm main.c
    $EW_DIR$/ARM/INC/siemens/: i2c.c
