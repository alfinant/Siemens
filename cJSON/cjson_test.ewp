# IAR project cjson_test.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; LUMBERG
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; NANO
  XLINK.XclFile: $TOOLKIT_DIR$\alfinant\Test\test.xcl
  group (top)
    ./: func.asm main.c undifined_functions.c
  group json
    json/: cJSON.c cJSON_Utils.c
