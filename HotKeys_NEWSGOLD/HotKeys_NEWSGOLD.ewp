# IAR project HotKeys_NEWSGOLD.ewp, settings and files
configuration S75v52 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; S75v52
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: "elf2vkp.exe" "$TARGET_PATH$" "$TARGET_DIR$\$TARGET_BNAME$.vkp" "$TOOLKIT_DIR$\bin\S75v52\S75v52.bin"
  XLINK.XclFile: config\S75v52.xcl
configuration E71v45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; E71v45
  postbuild: "elf2vkp.exe" "$TARGET_PATH$" "$TARGET_DIR$\$TARGET_BNAME$.vkp" "$TOOLKIT_DIR$\bin\E71v45\E71v45.bin"
  group (top)
    ./: main.c patch.asm
