# IAR project aes128_patch.ewp, settings and files
configuration S75sw52 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NEWSGOLD; S75v52
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: postbuild.cmd $PROJ_DIR$ $EXE_DIR$
  XLINK.XclFile: S75sw52.xcl
  group (top)
    ./: cryptlib.c e_aes.c err.c evp_enc.c main.c patch.asm ssl_ciph.c
  group aes
    aes/: aes_cbc.c aes_cfb.c aes_core.c aes_ctr.c aes_ecb.c aes_misc.c aes_ofb.c
