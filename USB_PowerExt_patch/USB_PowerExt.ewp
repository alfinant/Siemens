# IAR project USB_PowerExt.ewp, settings and files
configuration CX75v25 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: SGOLD; CX75v25
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: CX75v25
  postbuild: "elf2vkp.exe" "$TARGET_PATH$" "$TARGET_DIR$\$TARGET_BNAME$.vkp" "$TOOLKIT_DIR$\bin\CX75v25\CX75v25.bin"
  XLINK.XclFile: config\CX75v25.xcl
configuration CX70v56 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; CX70v56
  postbuild: "elf2vkp" CX70v56\Exe\Hotkeys.elf CX70v56\Exe\Hotkeys.vkp "$TOOLKIT_DIR$\bin\CX70v56\CX70v56.bin"
  XLINK.XclFile: config\CX70v56.xcl
  group (top)
    ./: patch.asm
