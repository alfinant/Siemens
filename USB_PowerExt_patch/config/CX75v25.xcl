-carm
-Z(CODE)ICODE,CODE,DATA_I,DATA_ID,INITTAB,DATA_C=A00A6890

-Z(CODE)PATCH_PhyWAS_ExtPower_Process_Entry=A0CF67A0
-Z(CODE)PATCH_Hisr_PhyWAS_ExtPower_Entry=A0A8EE9C

