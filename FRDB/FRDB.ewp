# IAR project FRDB.ewp, settings and files
configuration E71v45 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: postbuild.cmd
  XLINK.XclFile: E71v45.xcl
configuration S75v47 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\FRDB\E71v45.xcl
configuration S75v52 (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; S75v52
  XLINK.XclFile: C:\Users\Инсаф\Documents\Siemens\alfinant\FRDB\config\S75v52.xcl
  group (top)
    ./: additional.c main.asm
    $EW_DIR$/ARM/INC/: swilib.h
