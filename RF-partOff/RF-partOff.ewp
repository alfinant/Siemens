# IAR project RF-partOff.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: E:\Users\alfinant\Documents\Siemens\alfinant\RF-partOff\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  XLINK.XclFile: $TOOLKIT_DIR$\alfinant\RF-partOff\test.xcl
  group (top)
    ./: func.asm main.c
