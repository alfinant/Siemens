<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PWM_Test_Sound.ewp</path>
  </project>
  <batchBuild/>
</workspace>


