# IAR project LogSms.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: SGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ./: conf_loader.c config.c func.asm main.c strings.c
