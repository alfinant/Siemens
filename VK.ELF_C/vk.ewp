# IAR project vk.ewp, settings and files
configuration Releas_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; DEBUG
  ICCARM.IExtraOptions: --diag_suppress Pe301
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; DEBUG
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; X75; DEVELOP
  postbuild: post_cx75.cmd $TARGET_PATH$
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; DEVELOP
  postbuild: post_cx75.cmd $TARGET_PATH$
  group (top)
    ./: buffer.c conf_loader.c config.c conndata.c cookie.c debug_gui.c dyn_images.c dyn_theme.c func.asm htpp.c main.c Menu_About.c Menu_Chat.c Menu_Dialogs.c Menu_Friends.c Menu_Groups.c Menu_GroupWall.c Menu_Login.c Menu_Main.c parser_error.c parser_user.c parser_wall.c process.c socket_work.c ssl_work.c string_util.c url_utils.c vk_api.c vk_objects.c
  group json
    ./: anim_widget.c
    json/: cJSON.c cJSON_Utils.c
