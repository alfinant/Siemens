# IAR project ssc.ewp, settings and files
configuration Release NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\alfinant\SerialLib\DIF\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c ssc.asm
