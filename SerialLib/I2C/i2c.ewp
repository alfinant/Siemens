# IAR project i2c.ewp, settings and files
configuration Release_ELKA (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\alfinant\SerialLib\I2C\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm i2clib.c main.c
