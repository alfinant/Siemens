# IAR project CarControl2.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: SGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLDX75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75; SGOLD
configuration Release_NSG (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ./: conf_loader.c config.c func.asm i2c.c irq_work.c main.c meas.c sms.c strings.c
