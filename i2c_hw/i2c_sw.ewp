# IAR project i2c_sw.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpannl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; S75v52
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\Users\alfin_000\Documents\Siemens\alfinant\i2c_sw\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm I2C_SW.C main.c strings.c
