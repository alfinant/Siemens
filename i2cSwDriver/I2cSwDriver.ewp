# IAR project I2cSwDriver.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpannl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  group (top)
    ./: delay.asm func.asm I2C_SW.C I2CSW_TS.C main.c task.c
