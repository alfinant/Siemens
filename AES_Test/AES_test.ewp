# IAR project AES_test.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; LUMBERG
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; NANO
  XLINK.XclFile: $TOOLKIT_DIR$\alfinant\Test\test.xcl
  group (top)
    ./: func.asm main.c
  group openssl/crypto/aes
    ../openssl/crypto/aes/: aes_cbc.c aes_cfb.c aes_core.c aes_ctr.c aes_ecb.c aes_locl.h aes_misc.c aes_ofb.c
  group openssl/crypto/evp
    ../openssl/crypto/evp/: e_aes.c evp_enc.c
