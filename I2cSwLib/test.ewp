# IAR project test.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\Users\alfin_000\Documents\Siemens\alfinant\Test\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  XLINK.XclFile: test.xcl
  group (top)
    ./: func.asm I2cSwLib.c main.c
