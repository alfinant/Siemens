# IAR project CapCom.ewp, settings and files
configuration Release_NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpannl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; E71v45
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\alfinant\SerialLib\CapCom\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: SGOLD; CX75v25
  group (top)
    ./: func.asm i2c.c main.c
